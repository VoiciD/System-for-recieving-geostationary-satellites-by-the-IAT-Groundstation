options:
  parameters:
    generate_options: qt_gui
    id: SDR_Software
    output_language: python
    title: Not titled yet
  states: {}

blocks:
- name: bandwidth
  id: variable_qtgui_range
  parameters:
    label: Filter Bandwidth
    start: '1'
    step: '1'
    stop: 200e3
    value: 125e3
    widget: eng_slider
  states: {}
- name: center_frequency
  id: variable_qtgui_range
  parameters:
    label: Center Frequency
    start: 30e6
    step: '1'
    stop: 120e6
    value: 40e6
    widget: eng_slider
  states: {}
- name: channel_frequency
  id: variable_qtgui_range
  parameters:
    start: 30e6
    step: '1'
    stop: 120e6
    value: 39.9976e6
    widget: eng_slider
  states: {}
- name: demod
  id: variable_qtgui_chooser
  parameters:
    label: Demodulation
    label0: FM
    label1: SSB
    num_opts: '2'
    option0: '0'
    option1: '1'
    type: int
    value: '0'
  states: {}
- name: fft_band_filter
  id: variable_band_pass_filter_taps
  parameters:
    gain: '1.0'
    high_cutoff_freq: 2.7e3
    low_cutoff_freq: '100'
    samp_rate: 48e4
    type: complex_band_pass
    width: '200'
    win: window.WIN_HAMMING
  states: {}
- name: rf_gain
  id: variable_qtgui_range
  parameters:
    label: RF Gain
    rangeType: int
    start: '0'
    step: '1'
    stop: '30'
    value: '0'
  states: {}
- name: samp_rate
  id: variable
  parameters:
    value: 1e6
  states: {}
- name: ssb
  id: variable_qtgui_chooser
  parameters:
    label: SSB Chooser
    label0: USB
    label1: LSB
    num_opts: '2'
    option0: '0'
    option1: '1'
    type: real
    value: '0'
  states: {}
- name: volume
  id: variable_qtgui_range
  parameters:
    label: Volume
    start: '0'
    step: '0.1'
    stop: '1'
    value: '0.5'
    widget: eng_slider
  states: {}
- name: analog_fm_demod_cf_0
  id: analog_fm_demod_cf
  parameters:
    audio_decim: '10'
    audio_pass: '15000'
    audio_stop: '16000'
    chan_rate: 480e3
    deviation: '75000'
    gain: '1.0'
    tau: '75e-6'
  states: {}
- name: analog_sig_source_x_0
  id: analog_sig_source_x
  parameters:
    amp: '1'
    freq: center_frequency-channel_frequency
    offset: '0'
    phase: '0'
    samp_rate: samp_rate
    type: complex
    waveform: analog.GR_COS_WAVE
  states: {}
- name: audio_sink_0
  id: audio_sink
  parameters:
    samp_rate: '48000'
  states: {}
- name: band_pass_filter_0
  id: band_pass_filter
  parameters:
    decim: '1'
    gain: '1'
    high_cutoff_freq: bandwidth
    low_cutoff_freq: '200'
    samp_rate: samp_rate
    type: fir_filter_ccc
    width: '500'
    win: window.WIN_HAMMING
  states: {}
- name: blocks_complex_to_real_0
  id: blocks_complex_to_real
  parameters: {}
  states: {}
- name: blocks_multiply_const_vxx_0
  id: blocks_multiply_const_vxx
  parameters:
    const: volume
    type: float
  states: {}
- name: blocks_multiply_xx_0
  id: blocks_multiply_xx
  parameters:
    type: complex
  states: {}
- name: blocks_selector_0
  id: blocks_selector
  parameters:
    enabled: 'True'
    input_index: '0'
    num_inputs: '1'
    num_outputs: '2'
    output_index: demod
    type: complex
  states: {}
- name: blocks_selector_1
  id: blocks_selector
  parameters:
    enabled: 'True'
    input_index: ssb
    num_inputs: '2'
    num_outputs: '1'
    output_index: '0'
    type: complex
  states: {}
- name: blocks_selector_2
  id: blocks_selector
  parameters:
    enabled: 'True'
    input_index: demod
    num_inputs: '2'
    num_outputs: '1'
    output_index: '0'
    type: float
  states: {}
- name: blocks_swapiq_0
  id: blocks_swapiq
  parameters: {}
  states: {}
- name: freq_xlating_fir_filter_xxx_0
  id: freq_xlating_fir_filter_xxx
  parameters:
    center_freq: '0'
    decim: '5'
    samp_rate: samp_rate
    taps: '20'
    type: ccc
  states: {}
- name: low_pass_filter_0
  id: low_pass_filter
  parameters:
    cutoff_freq: bandwidth
    decim: '5'
    gain: '1'
    samp_rate: samp_rate
    type: fir_filter_ccf
    width: 25e3
    win: window.WIN_HAMMING
  states: {}
- name: osmosdr_source_0
  id: osmosdr_source
  parameters:
    bb_gain0: '0'
    bw0: samp_rate
    freq0: center_frequency
    gain0: rf_gain
    gain_mode0: 'False'
    if_gain0: '0'
    sample_rate: samp_rate
    sync: sync
    type: fc32
  states: {}
- name: qtgui_freq_sink_x_0
  id: qtgui_freq_sink_x
  parameters:
    bw: samp_rate
    fc: center_frequency
    fftsize: '1024'
    type: complex
  states: {}
- name: qtgui_freq_sink_x_0_0
  id: qtgui_freq_sink_x
  parameters:
    bw: samp_rate
    fc: '0'
    fftsize: '1024'
    freqhalf: 'False'
    type: float
  states: {}
- name: rational_resampler_xxx_0
  id: rational_resampler_xxx
  parameters:
    decim: '5'
    interp: '12'
    type: ccc
  states: {}
- name: rational_resampler_xxx_0_0
  id: rational_resampler_xxx
  parameters:
    decim: '25'
    interp: '6'
    type: ccc
  states: {}

connections:
- [analog_fm_demod_cf_0, '0', blocks_selector_2, '0']
- [analog_sig_source_x_0, '0', blocks_multiply_xx_0, '1']
- [band_pass_filter_0, '0', blocks_complex_to_real_0, '0']
- [blocks_complex_to_real_0, '0', blocks_selector_2, '1']
- [blocks_multiply_const_vxx_0, '0', audio_sink_0, '0']
- [blocks_multiply_xx_0, '0', blocks_selector_0, '0']
- [blocks_selector_0, '0', low_pass_filter_0, '0']
- [blocks_selector_0, '1', freq_xlating_fir_filter_xxx_0, '0']
- [blocks_selector_1, '0', rational_resampler_xxx_0_0, '0']
- [blocks_selector_2, '0', blocks_multiply_const_vxx_0, '0']
- [blocks_selector_2, '0', qtgui_freq_sink_x_0_0, '0']
- [blocks_swapiq_0, '0', blocks_selector_1, '1']
- [freq_xlating_fir_filter_xxx_0, '0', blocks_selector_1, '0']
- [freq_xlating_fir_filter_xxx_0, '0', blocks_swapiq_0, '0']
- [low_pass_filter_0, '0', rational_resampler_xxx_0, '0']
- [osmosdr_source_0, '0', blocks_multiply_xx_0, '0']
- [osmosdr_source_0, '0', qtgui_freq_sink_x_0, '0']
- [rational_resampler_xxx_0, '0', analog_fm_demod_cf_0, '0']
- [rational_resampler_xxx_0_0, '0', band_pass_filter_0, '0']

metadata:
  file_format: 1
  grc_version: 3.10.9.2
